Commit message: use more xacro macro to reduce lines of code

File: urdf/materials.xacro (robot description, xacro)
@@ -8,5 +8,5 @@
       <color rgba="1 1 1 1"/>
   </material>
-  <material name="gray">
+  <material name="grey">
       <color rgba="0.5 0.5 0.5 1"/>
   </material>
